# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

SUMMARY = "The grunt command line interface"
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# The following license files were not able to be identified and are
# represented as "Unknown" below, you will need to check them yourself:
#   node_modules/abbrev/LICENSE
#   node_modules/atob/LICENSE
#   node_modules/atob/LICENSE.DOCS
#   node_modules/source-map/LICENSE
#   node_modules/grunt-known-options/LICENSE
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "MIT & CLOSED & ISC"
LIC_FILES_CHKSUM = "file://node_modules/expand-brackets/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/expand-brackets/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/expand-brackets/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/path-root/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/braces/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/braces/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/for-own/LICENSE;md5=a9f606f2e3822130012aab1f9c6ed213 \
                    file://node_modules/split-string/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/nanomatch/LICENSE;md5=01a8b0026a66c0139b0434fba078fa92 \
                    file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/is-relative/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/detect-file/LICENSE;md5=aa4dcde4017ea222442bc37c2dacb36b \
                    file://node_modules/global-modules/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/urix/LICENSE;md5=7e0155ddd0674c6065b91c9a5a15798d \
                    file://node_modules/function-bind/LICENSE;md5=e7417c1a8ad83f88bcac21ad440d48b2 \
                    file://node_modules/resolve-dir/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/unset-value/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/unset-value/node_modules/has-value/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/unset-value/node_modules/has-value/node_modules/isobject/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/unset-value/node_modules/has-values/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/extglob/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/extglob/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/extglob/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/extglob/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/extglob/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/extglob/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/abbrev/LICENSE;md5=e9c0b639498fbe60d17b10099aba77c0 \
                    file://node_modules/expand-tilde/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/has-value/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/is-absolute/LICENSE;md5=b2593528953061a799b5b34922f0064d \
                    file://node_modules/parse-passwd/LICENSE;md5=1036373bcb7944578843baf629c16dbf \
                    file://node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/ret/LICENSE;md5=9aeada1cccf95163778a1c8189c8f297 \
                    file://node_modules/is-data-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/has/LICENSE-MIT;md5=d000afc3c9ff3501a5610197db76a246 \
                    file://node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/object.map/LICENSE;md5=62ea554942f7592db55834ba4499798b \
                    file://node_modules/liftoff/LICENSE;md5=976108e041d95aec03ec5c4246bad937 \
                    file://node_modules/array-each/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/resolve/LICENSE;md5=baa47288b5bd3e657a01886ce3dd0cb6 \
                    file://node_modules/set-value/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/set-value/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/to-regex-range/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/fragment-cache/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/mixin-deep/LICENSE;md5=4e0921625c33cf4e6990a6416848a6e5 \
                    file://node_modules/mixin-deep/node_modules/is-extendable/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/object.defaults/LICENSE;md5=a9f606f2e3822130012aab1f9c6ed213 \
                    file://node_modules/rechoir/LICENSE;md5=40a27083d1803ac85e6203f364a63088 \
                    file://node_modules/has-values/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/has-values/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/nopt/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/array-slice/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/get-value/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/map-visit/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/static-extend/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/static-extend/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/resolve-url/LICENSE;md5=7e0155ddd0674c6065b91c9a5a15798d \
                    file://node_modules/fill-range/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/fill-range/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/unc-path-regex/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/collection-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/object.pick/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/v8flags/LICENSE;md5=a23a40ab945d47b3d110800a06bd2bd2 \
                    file://node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/base/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/base/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/base/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/base/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/base/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/micromatch/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/decode-uri-component/license;md5=775415f59d9642dd552fd60e4c0adda4 \
                    file://node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/isexe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/arr-union/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/cache-base/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/copy-descriptor/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/global-prefix/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/object-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/source-map-resolve/LICENSE;md5=c71a7496543458e1dd6bf60d8224c813 \
                    file://node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/is-glob/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/posix-character-classes/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/atob/LICENSE;md5=493adefc1fe80b079a23203e4732d945 \
                    file://node_modules/atob/LICENSE.DOCS;md5=980f12f548ed1abbfc4771f40a8116d3 \
                    file://node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/to-regex/LICENSE;md5=01a8b0026a66c0139b0434fba078fa92 \
                    file://node_modules/path-parse/LICENSE;md5=4b940f9668dfcb796d2cb98ad94692df \
                    file://node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/use/LICENSE;md5=b561e0a423bedc9d9ca9c8c67d40abb9 \
                    file://node_modules/repeat-element/LICENSE;md5=b561e0a423bedc9d9ca9c8c67d40abb9 \
                    file://node_modules/path-root-regex/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/is-unc-path/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/os-homedir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/snapdragon/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/snapdragon/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/snapdragon/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/regex-not/LICENSE;md5=6c5e341361a86b6253a8e81978cbb67e \
                    file://node_modules/flagged-respawn/LICENSE;md5=a23a40ab945d47b3d110800a06bd2bd2 \
                    file://node_modules/osenv/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/repeat-string/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/is-accessor-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/fined/LICENSE;md5=0e3fd3bc075aa8679de16c734bc34198 \
                    file://node_modules/map-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/snapdragon-node/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/snapdragon-node/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/snapdragon-node/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/snapdragon-node/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/snapdragon-node/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/array-unique/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/os-tmpdir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/grunt-known-options/LICENSE;md5=331e7399a324dbd9645b0d949ab3996b \
                    file://node_modules/object-copy/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/object-copy/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/object-copy/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/interpret/LICENSE;md5=976108e041d95aec03ec5c4246bad937 \
                    file://node_modules/is-extglob/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/union-value/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/homedir-polyfill/LICENSE;md5=1036373bcb7944578843baf629c16dbf \
                    file://node_modules/assign-symbols/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/extend-shallow/LICENSE;md5=4e0921625c33cf4e6990a6416848a6e5 \
                    file://node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/source-map-url/LICENSE;md5=c5fd933c72ea96892cc6dcdcdd6c766f \
                    file://node_modules/parse-filepath/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/is-core-module/LICENSE;md5=02b0fb5ff4014a08fd4193bc3e2349e2 \
                    file://node_modules/pascalcase/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/safe-regex/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/class-utils/LICENSE;md5=ffc896391717b946ebe09615926637e1 \
                    file://node_modules/class-utils/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/which/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/define-property/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/define-property/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/define-property/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/arr-diff/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/make-iterator/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/snapdragon-util/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/snapdragon-util/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://package.json;md5=dcf8afca7b156adf6e92bb63987df2ce \
                    file://node_modules/abbrev/package.json;md5=09144e5559c19012a5ad2b1cb548f188 \
                    file://node_modules/arr-diff/package.json;md5=5ac535a60cd9b72b89f97eac2044c950 \
                    file://node_modules/arr-flatten/package.json;md5=7f21caea60a39f18e0d6f05d54396c11 \
                    file://node_modules/arr-union/package.json;md5=e30278a1b01880e0835afd3de59cf12d \
                    file://node_modules/array-each/package.json;md5=5ce5eb851a81c6797c03637edca23dce \
                    file://node_modules/array-slice/package.json;md5=757fcb64e993e3b89ae1b9804231f013 \
                    file://node_modules/array-unique/package.json;md5=8c59b5beb7fa949cd47ade511f823214 \
                    file://node_modules/assign-symbols/package.json;md5=f2fbb1be41769bcec4582073a3db8c8d \
                    file://node_modules/atob/package.json;md5=cad00c76eb03ce16bc9ca3a2e0ee982e \
                    file://node_modules/base/node_modules/define-property/package.json;md5=2afc9d66b46a8a1a06743d6004c27ecb \
                    file://node_modules/base/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/base/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/base/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/base/package.json;md5=4b68e486bb2271317f7373ffac92395d \
                    file://node_modules/braces/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/braces/package.json;md5=0956bb2b39c31ba39e7951b3c4c131c2 \
                    file://node_modules/cache-base/package.json;md5=f0150262ed8266c8c5c927b9de4d31b0 \
                    file://node_modules/class-utils/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/class-utils/package.json;md5=0de6151f3fbfd13c0a12004e8e754003 \
                    file://node_modules/collection-visit/package.json;md5=9cf59dca6759b69fe52c37f98b894962 \
                    file://node_modules/component-emitter/package.json;md5=81dd6df22a2628fa27a5c4937df567f6 \
                    file://node_modules/copy-descriptor/package.json;md5=ecd13fcc72056398f309b3be5c9e623c \
                    file://node_modules/debug/package.json;md5=71a7656944ffe50cc27ebe02491ae49b \
                    file://node_modules/decode-uri-component/package.json;md5=3c2da9242641c103907dee7ee36c36d9 \
                    file://node_modules/define-property/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/define-property/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/define-property/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/define-property/package.json;md5=29d59fea60bc8344de21b01b76768dbf \
                    file://node_modules/detect-file/package.json;md5=7ab62ddc763f8dc86884321c32f51d16 \
                    file://node_modules/expand-brackets/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/expand-brackets/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/expand-brackets/package.json;md5=117ad2f3da10271826c98537b0b7d62d \
                    file://node_modules/expand-tilde/package.json;md5=eba20b2403d3f862f288e355023608ac \
                    file://node_modules/extend/package.json;md5=5074ec873b4010df5203d20e73e65246 \
                    file://node_modules/extend-shallow/node_modules/is-extendable/package.json;md5=b569f78b3ad4a0c87d7e00873edab7da \
                    file://node_modules/extend-shallow/package.json;md5=c41732fba62098ae649aec68c78c7d01 \
                    file://node_modules/extglob/node_modules/define-property/package.json;md5=2afc9d66b46a8a1a06743d6004c27ecb \
                    file://node_modules/extglob/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/extglob/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/extglob/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/extglob/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/extglob/package.json;md5=d4f33fd0f4970db7bbc9a74b6c1ef530 \
                    file://node_modules/fill-range/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/fill-range/package.json;md5=663440166ce71901e0df47549bb99966 \
                    file://node_modules/findup-sync/package.json;md5=fe6383e674558568ba6374525cddd5ea \
                    file://node_modules/fined/package.json;md5=c7bdfeb7c96155f46b1f26cc74c17edb \
                    file://node_modules/flagged-respawn/package.json;md5=bf7faf89bcfa06639923dcd01d23f8a7 \
                    file://node_modules/for-in/package.json;md5=68d1bcc83288065fe21285a685c389c3 \
                    file://node_modules/for-own/package.json;md5=ba290fc030d591d46bd12ad03d608602 \
                    file://node_modules/fragment-cache/package.json;md5=90f40e0f75baceab0c48be8cc4a897a4 \
                    file://node_modules/function-bind/package.json;md5=f453e26c8d3482b4c3736f53303b4ec5 \
                    file://node_modules/get-value/package.json;md5=987510f1e53242ffe9851555ab3350a5 \
                    file://node_modules/global-modules/package.json;md5=1abfcfc0136cba481ae2304dcc0a26a0 \
                    file://node_modules/global-prefix/package.json;md5=311bdbe8c1125c2021e77920db9af22f \
                    file://node_modules/grunt-known-options/package.json;md5=f2e2223e18f32493c968a40bf8a63bdc \
                    file://node_modules/has/package.json;md5=2fee243336ba5aeebed1e0145472cd49 \
                    file://node_modules/has-value/package.json;md5=73de914f6546bc1c23de28d2ca03126e \
                    file://node_modules/has-values/node_modules/kind-of/package.json;md5=c80e6332d2836d915077531c8d1d72df \
                    file://node_modules/has-values/package.json;md5=3e492c1f66ae74b8e1fb0cf1f0be81e2 \
                    file://node_modules/homedir-polyfill/package.json;md5=ed52d1d049e9667e0dbb71e5674500b6 \
                    file://node_modules/ini/package.json;md5=c817b5b8913b3ab535d215aad84c3a7f \
                    file://node_modules/interpret/package.json;md5=c77bfa69f4a544598b9603f4e3be137a \
                    file://node_modules/is-absolute/package.json;md5=adf23a50e92728422cc4c8f8b4f67624 \
                    file://node_modules/is-accessor-descriptor/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/is-accessor-descriptor/package.json;md5=251b51bed1be5461844300dffb7156b0 \
                    file://node_modules/is-buffer/package.json;md5=b5faa5fac071732491a62f6168f3bae6 \
                    file://node_modules/is-core-module/package.json;md5=97aa22e215a261c79e452cc9120841e2 \
                    file://node_modules/is-data-descriptor/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/is-data-descriptor/package.json;md5=7e85bd6728bd7ee0297e85d1ecc173d7 \
                    file://node_modules/is-descriptor/node_modules/kind-of/package.json;md5=9c5fbbf74e4f49e6fc0dcd82ca1c7686 \
                    file://node_modules/is-descriptor/package.json;md5=5990d4cad3ecf89ee1864dcf10fc60cb \
                    file://node_modules/is-extendable/package.json;md5=0c2e213489eae83b656348e97ff8bbe8 \
                    file://node_modules/is-extglob/package.json;md5=90ad861bbbc1f6ee662d11dd78cdc2fd \
                    file://node_modules/is-glob/package.json;md5=71cd690e8d61d506b7386ca44e6a4405 \
                    file://node_modules/is-number/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/is-number/package.json;md5=34f310b6d2cfde34f4f0db50ad254851 \
                    file://node_modules/is-plain-object/package.json;md5=9d4258679c223aa77b7db3d91796ce6f \
                    file://node_modules/is-relative/package.json;md5=7b057b23a10fa1d9df473f65f65745a2 \
                    file://node_modules/is-unc-path/package.json;md5=91958b5b9765eca54085ec03d86bac4f \
                    file://node_modules/is-windows/package.json;md5=5a2ed52f501e3a4a772b50bf34c752eb \
                    file://node_modules/isarray/package.json;md5=a490f11007b2cc9d19c4a250592c2e71 \
                    file://node_modules/isexe/package.json;md5=b7340828ee0e123814f9b855953de714 \
                    file://node_modules/isobject/package.json;md5=6f27623b2c39dde8a528a8446e4f2cc1 \
                    file://node_modules/kind-of/package.json;md5=0eadbbda9b0d0f582c6bc804ff959e63 \
                    file://node_modules/liftoff/package.json;md5=536608cab3a02efd91026e57b164934a \
                    file://node_modules/make-iterator/package.json;md5=6ceef7309a63fa36f5d5bb22b4f77bc7 \
                    file://node_modules/map-cache/package.json;md5=acd7503821d165d4848314e17c612ce1 \
                    file://node_modules/map-visit/package.json;md5=8fbba381ef7e234051cc98e7f7251ca3 \
                    file://node_modules/micromatch/package.json;md5=b9cec2ad4947c01f579f8248fcd3d359 \
                    file://node_modules/mixin-deep/node_modules/is-extendable/package.json;md5=b569f78b3ad4a0c87d7e00873edab7da \
                    file://node_modules/mixin-deep/package.json;md5=897a790e3d3372fd83dcd67f35749d55 \
                    file://node_modules/ms/package.json;md5=cbd55880a650b56c3d5acddbbdbee9bc \
                    file://node_modules/nanomatch/package.json;md5=6aaee43183e8a7c47d2b610952bb870f \
                    file://node_modules/nopt/package.json;md5=5192f3f2450d866a1118c12915c38e37 \
                    file://node_modules/object-copy/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/object-copy/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/object-copy/package.json;md5=89b7b1d90d56bb98ef517f52801cf1b6 \
                    file://node_modules/object-visit/package.json;md5=abd0bdc0f3cfea9705a82e9bc14038d3 \
                    file://node_modules/object.defaults/package.json;md5=2d593b248eec2604594110156fd31769 \
                    file://node_modules/object.map/package.json;md5=505e339c9d04e38fa015d615e7a3a4ce \
                    file://node_modules/object.pick/package.json;md5=f4387ea465f917e297581815a19748aa \
                    file://node_modules/os-homedir/package.json;md5=cfc8a815cbc6e35583981f3006bfabd5 \
                    file://node_modules/os-tmpdir/package.json;md5=20555f37b3809082d0562ce7f144a04a \
                    file://node_modules/osenv/package.json;md5=4690af52479190b37d7e5df62fa167d8 \
                    file://node_modules/parse-filepath/package.json;md5=1b1f157b187eb883aed66875499193d2 \
                    file://node_modules/parse-passwd/package.json;md5=e4f3548179bb6ceeeb6e48669652cc87 \
                    file://node_modules/pascalcase/package.json;md5=933964e8e6b0c51fe219f7ea58002d18 \
                    file://node_modules/path-parse/package.json;md5=63b66a2ecf520db6b1a3246bafd6f4bc \
                    file://node_modules/path-root/package.json;md5=8e6531106f404a99a6d6f7c2260c8add \
                    file://node_modules/path-root-regex/package.json;md5=5e25a1a00b89fbb77bb8073949a7c0de \
                    file://node_modules/posix-character-classes/package.json;md5=90be4a75261123c121d1bd26a300da0e \
                    file://node_modules/rechoir/package.json;md5=c61a6ae9f08c752ab6bca5ab942c1dc8 \
                    file://node_modules/regex-not/package.json;md5=ef993e8d2313a18591d9fc36bfe1635d \
                    file://node_modules/repeat-element/package.json;md5=bfba170ea7d20c1d85f4bf34582fcdae \
                    file://node_modules/repeat-string/package.json;md5=bc161704e452cf4ab0e6d92a3f93881c \
                    file://node_modules/resolve/package.json;md5=4f233367dfd4362297ee8924a7cd9257 \
                    file://node_modules/resolve-dir/package.json;md5=e1e60ea79b6e3f1d384e3d2de6c38185 \
                    file://node_modules/resolve-url/package.json;md5=9bdafeb86a13dd230ba11d4666fb83bc \
                    file://node_modules/ret/package.json;md5=873a515c64ff7e8be55f58d339eb65e4 \
                    file://node_modules/safe-regex/package.json;md5=2d61123b0dab764e2d02612602ebc8d3 \
                    file://node_modules/set-value/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/set-value/package.json;md5=71dd072568acbcd8f492a8d90483126e \
                    file://node_modules/snapdragon/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/snapdragon/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/snapdragon/package.json;md5=aac08bb9849bebee9a80da1c3d7a8db7 \
                    file://node_modules/snapdragon-node/node_modules/define-property/package.json;md5=2afc9d66b46a8a1a06743d6004c27ecb \
                    file://node_modules/snapdragon-node/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/snapdragon-node/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/snapdragon-node/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/snapdragon-node/package.json;md5=0e4c7ad2db6cf7523395af399b395b51 \
                    file://node_modules/snapdragon-util/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/snapdragon-util/package.json;md5=6f3bb6a1b60d3223ec551b638c94bca0 \
                    file://node_modules/source-map/package.json;md5=7d1d048f81843bb704a2c69b3bcf3018 \
                    file://node_modules/source-map-resolve/package.json;md5=7fa43e9a62b9276ac92526ad8d65eb34 \
                    file://node_modules/source-map-url/package.json;md5=adfc3cb9d58f86534adee1eec2f6b392 \
                    file://node_modules/split-string/package.json;md5=aa98d5fde5aca0766cb64853830f0b78 \
                    file://node_modules/static-extend/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/static-extend/package.json;md5=d5e2273820801342d4944b0cc9d19dee \
                    file://node_modules/to-object-path/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/to-object-path/package.json;md5=ef9676c6bb6427cc27f317f7b62e7a84 \
                    file://node_modules/to-regex/package.json;md5=fd669d7faf4a90d37352d703bb2bc9c6 \
                    file://node_modules/to-regex-range/package.json;md5=78cf87351f668406995d7d666300de60 \
                    file://node_modules/unc-path-regex/package.json;md5=ce8dab00313733f52f6be99f46393afa \
                    file://node_modules/union-value/package.json;md5=15f1461213c2ec9b21456f0965762346 \
                    file://node_modules/unset-value/node_modules/has-value/node_modules/isobject/package.json;md5=1f7c913a432a69e21c1e9734c5f85d8e \
                    file://node_modules/unset-value/node_modules/has-value/package.json;md5=92eeafb383aad6f36aedb6af1bc14b2f \
                    file://node_modules/unset-value/node_modules/has-values/package.json;md5=af83c2d5df207a2d3328235a597f264c \
                    file://node_modules/unset-value/package.json;md5=e8fb535f29316c949173b5ed2a6fa746 \
                    file://node_modules/urix/package.json;md5=6efbf375a06ebd1c6339c263642345ce \
                    file://node_modules/use/package.json;md5=cb9a06a7080529dd1dd80436bc2dd5d4 \
                    file://node_modules/v8flags/package.json;md5=57a3907c268b2cab74f24c6e24860316 \
                    file://node_modules/which/package.json;md5=9db3fcd8026f288ba3aaad83200f5a35"

SRC_URI = " \
    npm://registry.npmjs.org/;package=grunt-cli;version=${PV} \
    "
NPM_SHRINKWRAP := "${THISDIR}/${PN}/npm-shrinkwrap.json"
S = "${WORKDIR}/npm"

inherit npm

RDEPENDS_${PN} += "bash zsh"

LICENSE_${PN} = "CLOSED"
LICENSE_${PN}-abbrev = "CLOSED"
LICENSE_${PN}-arr-diff = "MIT"
LICENSE_${PN}-arr-flatten = "MIT"
LICENSE_${PN}-arr-union = "MIT"
LICENSE_${PN}-array-each = "MIT"
LICENSE_${PN}-array-slice = "MIT"
LICENSE_${PN}-array-unique = "MIT"
LICENSE_${PN}-assign-symbols = "MIT"
LICENSE_${PN}-atob = "CLOSED"
LICENSE_${PN}-base-define-property = "MIT"
LICENSE_${PN}-base-is-accessor-descriptor = "MIT"
LICENSE_${PN}-base-is-data-descriptor = "MIT"
LICENSE_${PN}-base-is-descriptor = "MIT"
LICENSE_${PN}-base = "MIT"
LICENSE_${PN}-braces-extend-shallow = "MIT"
LICENSE_${PN}-braces = "MIT"
LICENSE_${PN}-cache-base = "MIT"
LICENSE_${PN}-class-utils-define-property = "MIT"
LICENSE_${PN}-class-utils = "MIT"
LICENSE_${PN}-collection-visit = "MIT"
LICENSE_${PN}-component-emitter = "MIT"
LICENSE_${PN}-copy-descriptor = "MIT"
LICENSE_${PN}-debug = "MIT"
LICENSE_${PN}-decode-uri-component = "MIT"
LICENSE_${PN}-define-property-is-accessor-descriptor = "MIT"
LICENSE_${PN}-define-property-is-data-descriptor = "MIT"
LICENSE_${PN}-define-property-is-descriptor = "MIT"
LICENSE_${PN}-define-property = "MIT"
LICENSE_${PN}-detect-file = "MIT"
LICENSE_${PN}-expand-brackets-define-property = "MIT"
LICENSE_${PN}-expand-brackets-extend-shallow = "MIT"
LICENSE_${PN}-expand-brackets = "MIT"
LICENSE_${PN}-expand-tilde = "MIT"
LICENSE_${PN}-extend = "MIT"
LICENSE_${PN}-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-extend-shallow = "MIT"
LICENSE_${PN}-extglob-define-property = "MIT"
LICENSE_${PN}-extglob-extend-shallow = "MIT"
LICENSE_${PN}-extglob-is-accessor-descriptor = "MIT"
LICENSE_${PN}-extglob-is-data-descriptor = "MIT"
LICENSE_${PN}-extglob-is-descriptor = "MIT"
LICENSE_${PN}-extglob = "MIT"
LICENSE_${PN}-fill-range-extend-shallow = "MIT"
LICENSE_${PN}-fill-range = "MIT"
LICENSE_${PN}-findup-sync = "CLOSED"
LICENSE_${PN}-fined = "MIT"
LICENSE_${PN}-flagged-respawn = "MIT"
LICENSE_${PN}-for-in = "MIT"
LICENSE_${PN}-for-own = "MIT"
LICENSE_${PN}-fragment-cache = "MIT"
LICENSE_${PN}-function-bind = "MIT"
LICENSE_${PN}-get-value = "MIT"
LICENSE_${PN}-global-modules = "MIT"
LICENSE_${PN}-global-prefix = "MIT"
LICENSE_${PN}-grunt-known-options = "CLOSED"
LICENSE_${PN}-has = "MIT"
LICENSE_${PN}-has-value = "MIT"
LICENSE_${PN}-has-values-kind-of = "MIT"
LICENSE_${PN}-has-values = "MIT"
LICENSE_${PN}-homedir-polyfill = "MIT"
LICENSE_${PN}-ini = "ISC"
LICENSE_${PN}-interpret = "MIT"
LICENSE_${PN}-is-absolute = "MIT"
LICENSE_${PN}-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-is-accessor-descriptor = "MIT"
LICENSE_${PN}-is-buffer = "MIT"
LICENSE_${PN}-is-core-module = "MIT"
LICENSE_${PN}-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-is-data-descriptor = "MIT"
LICENSE_${PN}-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-is-descriptor = "MIT"
LICENSE_${PN}-is-extendable = "MIT"
LICENSE_${PN}-is-extglob = "MIT"
LICENSE_${PN}-is-glob = "MIT"
LICENSE_${PN}-is-number-kind-of = "MIT"
LICENSE_${PN}-is-number = "MIT"
LICENSE_${PN}-is-plain-object = "MIT"
LICENSE_${PN}-is-relative = "MIT"
LICENSE_${PN}-is-unc-path = "MIT"
LICENSE_${PN}-is-windows = "MIT"
LICENSE_${PN}-isarray = "CLOSED"
LICENSE_${PN}-isexe = "ISC"
LICENSE_${PN}-isobject = "MIT"
LICENSE_${PN}-kind-of = "MIT"
LICENSE_${PN}-liftoff = "MIT"
LICENSE_${PN}-make-iterator = "MIT"
LICENSE_${PN}-map-cache = "MIT"
LICENSE_${PN}-map-visit = "MIT"
LICENSE_${PN}-micromatch = "MIT"
LICENSE_${PN}-mixin-deep-is-extendable = "MIT"
LICENSE_${PN}-mixin-deep = "MIT"
LICENSE_${PN}-ms = "MIT"
LICENSE_${PN}-nanomatch = "MIT"
LICENSE_${PN}-nopt = "ISC"
LICENSE_${PN}-object-copy-define-property = "MIT"
LICENSE_${PN}-object-copy-kind-of = "MIT"
LICENSE_${PN}-object-copy = "MIT"
LICENSE_${PN}-object-visit = "MIT"
LICENSE_${PN}-objectdefaults = "MIT"
LICENSE_${PN}-objectmap = "MIT"
LICENSE_${PN}-objectpick = "MIT"
LICENSE_${PN}-os-homedir = "MIT"
LICENSE_${PN}-os-tmpdir = "MIT"
LICENSE_${PN}-osenv = "ISC"
LICENSE_${PN}-parse-filepath = "MIT"
LICENSE_${PN}-parse-passwd = "MIT"
LICENSE_${PN}-pascalcase = "MIT"
LICENSE_${PN}-path-parse = "MIT"
LICENSE_${PN}-path-root = "MIT"
LICENSE_${PN}-path-root-regex = "MIT"
LICENSE_${PN}-posix-character-classes = "MIT"
LICENSE_${PN}-rechoir = "MIT"
LICENSE_${PN}-regex-not = "MIT"
LICENSE_${PN}-repeat-element = "MIT"
LICENSE_${PN}-repeat-string = "MIT"
LICENSE_${PN}-resolve = "MIT"
LICENSE_${PN}-resolve-dir = "MIT"
LICENSE_${PN}-resolve-url = "MIT"
LICENSE_${PN}-ret = "MIT"
LICENSE_${PN}-safe-regex = "MIT"
LICENSE_${PN}-set-value-extend-shallow = "MIT"
LICENSE_${PN}-set-value = "MIT"
LICENSE_${PN}-snapdragon-define-property = "MIT"
LICENSE_${PN}-snapdragon-extend-shallow = "MIT"
LICENSE_${PN}-snapdragon = "MIT"
LICENSE_${PN}-snapdragon-node-define-property = "MIT"
LICENSE_${PN}-snapdragon-node-is-accessor-descriptor = "MIT"
LICENSE_${PN}-snapdragon-node-is-data-descriptor = "MIT"
LICENSE_${PN}-snapdragon-node-is-descriptor = "MIT"
LICENSE_${PN}-snapdragon-node = "MIT"
LICENSE_${PN}-snapdragon-util-kind-of = "MIT"
LICENSE_${PN}-snapdragon-util = "MIT"
LICENSE_${PN}-source-map = "CLOSED"
LICENSE_${PN}-source-map-resolve = "MIT"
LICENSE_${PN}-source-map-url = "MIT"
LICENSE_${PN}-split-string = "MIT"
LICENSE_${PN}-static-extend-define-property = "MIT"
LICENSE_${PN}-static-extend = "MIT"
LICENSE_${PN}-to-object-path-kind-of = "MIT"
LICENSE_${PN}-to-object-path = "MIT"
LICENSE_${PN}-to-regex = "MIT"
LICENSE_${PN}-to-regex-range = "MIT"
LICENSE_${PN}-unc-path-regex = "MIT"
LICENSE_${PN}-union-value = "MIT"
LICENSE_${PN}-unset-value-has-value-isobject = "MIT"
LICENSE_${PN}-unset-value-has-value = "MIT"
LICENSE_${PN}-unset-value-has-values = "MIT"
LICENSE_${PN}-unset-value = "MIT"
LICENSE_${PN}-urix = "MIT"
LICENSE_${PN}-use = "MIT"
LICENSE_${PN}-v8flags = "MIT"
LICENSE_${PN}-which = "ISC"
