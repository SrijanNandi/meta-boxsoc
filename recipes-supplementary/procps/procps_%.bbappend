PR = "r.2"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://sysctl.conf"
