SYSTEMD_AUTO_ENABLE_${PN}-daemon = "disable"
SYSTEMD_AUTO_ENABLE_${PN}-dnsconfd ="disable"
